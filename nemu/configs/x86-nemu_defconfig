## nemu/configs/x86-nemu_defconfig
```kconfig
CONFIG_ISA_x86=y
CONFIG_TARGET_NATIVE_ELF=y
# CONFIG_TRACE is not set
CONFIG_MSIZE=0x2000000
CONFIG_DEVICE=y
```
